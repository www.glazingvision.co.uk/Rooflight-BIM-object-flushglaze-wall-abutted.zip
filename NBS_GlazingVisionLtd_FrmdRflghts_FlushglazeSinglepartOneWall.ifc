Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-01-25T15:51:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Wed Jan 25 15:51:40 2017* Host: NCL-PI08* Database: C:\Users\KovacsG\AppData\Local\Temp\{77F0412F-E99F-4941-B3BD-5A20B225CCF0}\ifc* Database version: 5507* Database creation date: Wed Jan 25 15:51:40 2017* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Wed Jan 25 15:51:40 2017* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Wed Jan 25 15:51:40 2017* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: X:\NBL\Manufacturer\G\Glazing Vision_12688\NBLA0680\Authoring\IFC\NBS_GlazingVisionLtd_FrmdRflghts_FlushglazeSinglepartOneWall.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcWindow: DoubleGlazed-1200x1200mm_6-16-6mm, NBS_GlazingVisionLtd_FrmdRflghts_FlushglazeSinglepartOneWall:DoubleGlazed-1200x1200mm_6-16-6mm:186918
In: Level 1
Type - ConstructionType: OTHER_CONSTRUCTION; OperationType: SINGLE_PANEL; ParameterTakesPrecedence: no; Sizeable: no; Classification: Pr_30_59_72_31 (Uniclass2015); Material: NBS_Glass_Double, NBS_Concept
Type - NBS_General - Author: NBS; BIMObjectName: NBS_GlazingVisionLtd_FramedRooflights_FlushglazeSinglepartOneWall_DoubleGlazed; ManufacturerName: Glazing Vision Ltd; ManufacturerURL: www.glazingvision.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/v4lxekwy; NBSDescription: Framed rooflights; NBSNote: 45-25-99/360 Aluminium frame roof windows; NBSOfficeMasterTag: n/a; NBSReference: 45-25-99/410; NBSTypeID: n/a; ProductInformation: www.glazingvision.co.uk/wp-content/uploads/2014/02/FG-DGU-TDS-Flushglaze-double-glazed-product-data-sheet-v3.1.pdf; Revision: n/a; Uniclass2015Code: Pr_30_59_72_31; Uniclass2015Title: Framed rooflights; Uniclass2015Version: Products v1.3; Version: 1
Type - NBS_Data - Accessories: Kerb top trim cover; CavityType: 16 mm black silicone sealed warm edge argon filled; Certification: BBA Certificate, SBD approved, Loss Prevention Certification Board certified (glass specification applies); DesignLoads: n/a; Form: Flat square or rectangular; FrameFinishCoating: Qualicoat approved polyester powder coating; FrameFinishColour: RAL7015 Slate Grey; FrameFinishTexture: n/a; FrameMaterial: Aluminium; GlazingOptions: Double, triple, walk-on, fire rated, Secured by Design; GlazingOrInfillCoating: Low-e coating; GlazingOrInfillConstruction: Double glazed; GlazingOrInfillType: Insulating glass units; InnerPaneType: 6 mm heat soak tested soft low e toughened; IntermediatePaneType: n/a; LightTransmission: 0.77; MaximumArea: 5.2 m² based on standard 6/16/6 glass spec; MaximumSize: 4000 mm; MinimumSize: 400 mm; OperationControl: n/a; OperationType: Fixed; OuterPaneType: 6 mm heat soak tested toughened; PitchAngleRange: 3-70°; RooflightWeight: 57 kg (1200 x 1200 mm); Seals: Silicone, butyl and rubber seals; ShadingCoefficient: 0; StructuralKerb: To builders kerb (by others) min 75 mm wide, 150 mm high, 3° pitch; ThermalBreak: yes; WholeWindowUValue: 1.5 W/m²K Uw
Type - Pset_WindowCommon - AcousticRating: 31 db; FireRating: n/a; GlazingAreaFraction: 0; Infiltration: 0; IsExternal: yes; Reference: n/a; SecurityRating: LPS2081 Issue 1:2015 (with laminated glass spec), approved Secured by Design; SmokeStop: no; ThermalTransmittance: 1.1
Type - Pset_DoorWindowGlazingType - BeamRadiationTransmittance: 0; FillGas: Argon; GlassColor: Clear; GlassLayers: 2; GlassThickness1: 6 mm; GlassThickness2: 6 mm; GlassThickness3: 0 mm; IsCoated: yes; IsLaminated: no; IsTempered: yes; IsWired: no; Reflectivity: 0; SolarHeatGainTransmittance: 0; ThermalTransmittanceSummer: 0; ThermalTransmittanceWinter: 0; Translucency: 0
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_30_59_72_31: Framed rooflights; CodePerformance: To BRE approved document Q; Color: Grey frame, clear glass; Constituents: Aluminium frame, double IGU; Description: Double glazed fixed rooflight designed to provide maximum daylight with minimal internal structure abutting one wall; DurationUnit: year; ExpectedLife: n/a; Features: No visible internal framework, no external capping, heat soak tested low e safety glass as standard; Finish: n/a; Grade: n/a; Manufacturer: sales@glazingvision.co.uk; Material: Aluminium, glass; ModelNumber: 402; ModelReference: GV Flushglaze Singlepart One Wall Double Glazed Rooflight; Name: FramedRooflights_FlushglazeSinglepartOneWall_DoubleGlazed_GlazingVisionLtd; NominalHeight: 0 mm; NominalLength: 1200 mm; NominalWidth: 1200 mm; ReplacementCost: n/a; Shape: Rectangular; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: Manufacturer's warranty; WarrantyDurationLabor: n/a; WarrantyDurationParts: 2 (installed by others) or 10 years (installed by Glazing Vision); WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: customerservices@glazingvision.co.uk
OverallHeight: 263.311 mm; OverallWidth: 1200 mm
NBS_Data - ComponentNumber: n/a; WindowNumber: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
